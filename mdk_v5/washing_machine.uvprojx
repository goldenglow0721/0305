# Keil uVision project washing_machine.uvprojx, settings and files
target SZK_VP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.6
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: washing_machine +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1,LCD_2_8_INCH_DEFINE=0
  c misc: --locale=english
  c include: ..\freertos;..\freertos\source\include;..\freertos\source\portable\memmang;..\freertos\source\portable\rvds\ARM_CM4F;.\APP;.\BSP;.\GT-HMI-Engine;.\GT-HMI-Engine\driver;.\GT-HMI-Engine\src;.\GT-HMI-Engine\src\core;.\GT-HMI-Engine\src\extra;.\GT-HMI-Engine\src\extra\draw;.\GT-HMI-Engine\src\extra\gif;.\GT-HMI-Engine\src\extra\jpeg;.\GT-HMI-Engine\src\extra\png;.\GT-HMI-Engine\src\font;.\GT-HMI-Engine\src\hal;.\GT-HMI-Engine\src\others;.\GT-HMI-Engine\src\utils;.\GT-HMI-Engine\src\widgets;.\libraries\cmsis\cm4\core_support;.\libraries\cmsis\cm4\device_support;.\libraries\cmsis\dsp\ComputeLibrary\Include;.\libraries\cmsis\dsp\include;.\libraries\cmsis\dsp\PrivateInclude;.\libraries\cmsis\dsp\Source\DistanceFunctions;.\libraries\drivers\inc;.\ui;..\freertos\source;..\mybsp;..\middlewares\fatfs\source;..\usb\usb_class;..\usb\usb_drivers\inc;..\usb\composite_cdc_msc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group GT-HMI-Engine/driver
    ./GT-HMI-Engine/driver/: gt_port_disp.c gt_port_indev.c gt_port_src.c gt_port_vf.c gt_gui_driver.lib
  group GT-HMI-Engine/src/core
    ./GT-HMI-Engine/src/core/: gt_disp.c gt_draw.c gt_event.c gt_fs.c gt_graph_base.c gt_handler.c gt_img_decoder.c gt_indev.c gt_mem.c gt_obj_pos.c gt_obj_scroll.c gt_refr.c gt_style.c gt_timer.c gt_scr_stack.c gt_layout.c
  group GT-HMI-Engine/src/extra
    ./GT-HMI-Engine/src/extra/: gt_extra.c
  group GT-HMI-Engine/src/extra/draw
    ./GT-HMI-Engine/src/extra/draw/: gt_draw_blend.c gt_draw_blend_with_rgb565.c
  group GT-HMI-Engine/src/extra/gif
    ./GT-HMI-Engine/src/extra/gif/: gifdec.c
  group GT-HMI-Engine/src/extra/jpeg
    ./GT-HMI-Engine/src/extra/jpeg/: gt_sjpg.c tjpgd.c
  group GT-HMI-Engine/src/extra/png
    ./GT-HMI-Engine/src/extra/png/: gt_png.c lodepng.c
  group GT-HMI-Engine/src/font
    ./GT-HMI-Engine/src/font/: gt_font.c gt_symbol.c
  group GT-HMI-Engine/src/hal
    ./GT-HMI-Engine/src/hal/: gt_hal_disp.c gt_hal_fs.c gt_hal_indev.c gt_hal_src.c gt_hal_tick.c gt_hal_vf.c
  group GT-HMI-Engine/src/others
    ./GT-HMI-Engine/src/others/: gt_anim.c gt_area.c gt_color.c gt_effects.c gt_gc.c gt_ll.c gt_math.c gt_tlsf.c gt_txt.c
  group GT-HMI-Engine/src/utils
    ./GT-HMI-Engine/src/utils/: gt_vector.c gt_stack.c
  group GT-HMI-Engine/src/widgets
    ./GT-HMI-Engine/src/widgets/: gt_barcode.c gt_btn.c gt_checkbox.c gt_clock.c gt_gif.c gt_group.c gt_img.c gt_imgbtn.c gt_input.c gt_input_number.c gt_keypad.c gt_label.c gt_line.c gt_listview.c gt_obj.c gt_obj_class.c gt_option.c gt_player.c gt_progress_bar.c gt_qrcode.c gt_radio.c gt_rect.c gt_roller.c gt_slider.c gt_switch.c gt_template.c gt_textarea.c gt_view_pager.c gt_wordart.c gt_btnmap.c gt_dialog.c gt_status_bar.c
  group libraries/cmsis/cm4/device_support
    ./libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ./libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group libraries/drivers/src
    ./libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group BSP
    ./BSP/: at32f403a_407_board.c bsp_lcd_xmc.c bsp_qspi_flash.c bsp_xpt2046.c touch.c
  group APP
    ./APP/: audio_manage.c battery_manage.c clock_manage.c gpio_manage.c HX711.c init_manage.c key_manage.c main.c motor_manage.c protocol.c spi.c timer_manage.c UltraSonic.c infusion.c OptoCoupler_manage.c alarm.c rtc.c CRC.c vp_button.c fatfs_history.c motor_detection.c
  group ui
    ./ui/: activity_AAAMainScreen.c headbar_view.c activity_BrandChioce.c activity_BrandChoice2.c activity_ClearAccumVol.c activity_DripMode.c activity_GeneralBolus.c activity_GeneralBolusRun.c activity_HistoryView.c activity_keyboard_float.c activity_keyboard_int.c activity_keyboard_Password.c activity_keyboard_soft.c activity_keyboard_time.c activity_ModeSelect.c activity_NightSetting.c activity_ParamSetting1.c activity_ParamSetting2.c activity_ParamSetting3.c activity_PressureNumSel.c activity_PressureUnit.c activity_Purge.c activity_PurgeRun.c activity_PurgeSizeSetting.c activity_SeqBolus.c activity_SeqBolusRun.c activity_SeqMode.c activity_SeqModeRun.c activity_SpeedMode.c activity_SystemDataSetting.c activity_SystemDataTimeSetting.c activity_SystemLanguageSetting.c activity_SystemSetting1.c activity_SystemSetting2.c activity_TimeMode.c activity_Version.c temp.c ui.c activity_AccuracyCalibrate1.c activity_AccuracyCalibrate2.c activity_AccuracyCalibrate2_1.c activity_AccuracyCalibrate3.c activity_Maintenance1_1.c activity_AccuracyCalibrate4.c activity_DeleteHistory.c activity_DoseUnit.c activity_DrugChoice.c activity_DrugUnit.c activity_Maintenance1_2.c activity_Maintenance1_3.c activity_Maintenance1_4.c activity_Maintenance2_1.c activity_Maintenance2_2.c activity_RestoreFactory.c activity_WeightMode.c activity_WeightModeRun.c activity_WeightMode2.c activity_PressureCalibrate1.c activity_PressureCalibrate2.c activity_Logo.c activity_DripModeRun.c activity_SpeedAndTimeModeRun.c library_drug.c library_infusion.c activity_ExportHistory.c activity_ParamSetting4.c activity_SystemCheck.c activity_Maintenance1_5.c activity_shutdown.c activity_SensorMonitor.c activity_Drugdelete.c activity_KVORun.c dialog1.c activity_DeleteBrand.c library_history.c activity_Standby.c BootUp.c activity_PowerOff.c
  group freertos
    ../freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freertos/source/portable/memmang/: heap_4.c
    ../freertos/source/portable/rvds/ARM_CM4F/: port.c
  group fatfs
    ../middlewares/fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group mybsp
    ../mybsp/: my_flash.c sleep_mode.c voltage_detection.c bsp_usb.c data_check.c
  group usb_driver
    ../usb/usb_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group usb_class
    ../usb/composite_cdc_msc/: cdc_msc_class.c cdc_msc_desc.c msc_bot_scsi.c
    ../usb/usb_class/: msc_diskio.c
